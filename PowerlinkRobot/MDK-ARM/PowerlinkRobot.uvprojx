# Keil uVision project PowerlinkRobot.uvprojx, settings and files
target PowerlinkRobot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: PowerlinkRobot
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99 --gnu
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\..\bldcSTM32\bldcSTM32\Inc;..\..\bldcSTM32\bldcSTM32\System;..\..\bldcSTM32\bldcSTM32\Drivers\BLDC\Inc;..\..\bldcSTM32\bldcSTM32\Drivers\HWConfig\Inc;..\..\openPowerlinkLwip\openPowerlinkLwip\Inc;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\Include;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\Include\kernel;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\Edrv;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\ObjDicts\Api_CN;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\ObjDicts\Generic;..\..\openPowerlinkLwip\openPowerlinkLwip\Drivers\openPOWERLINK\Target\STM32F407
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/BLDC
    ../../bldcSTM32/bldcSTM32/Drivers/BLDC/Src/: buffer.c comm_can.c comm_usb.c commands.c conf_general.c crc.c digital_filter.c eeprom.c encoder.c flash_helper.c irq_handlers.c led_external.c ledpwm.c mc_interface.c mcpwm.c mcpwm_foc.c packet.c servo.c servo_dec.c servo_simple.c terminal.c timeout.c utils.c ws2811.c
  group Drivers/HWConfig
    ../../bldcSTM32/bldcSTM32/Drivers/HWConfig/Src/: hw_48.c
  group OpenPOWERLINK/EplStack
    ../../openPowerlinkLwip/openPowerlinkLwip/Drivers/openPOWERLINK/EplStack/: amiarm.c EplApiFreeRTOS.c EplApiGeneric.c EplApiProcessImage.c EplDllk.c EplDllkCal.c EplDlluCal.c EplErrorHandlerk.c EplEventk.c EplEventu.c EplIdentu.c EplLedu.c EplNmtCnu.c EplNmtk.c EplNmtkCal.c EplNmtMnu.c EplNmtu.c EplNmtuCal.c EplObd.c EplObdkCal.c EplObdu.c EplObduCal.c EplPdok.c EplPdokCal.c EplPdou.c EplPdouCal.c EplSdoAsndu.c EplSdoAsySequ.c EplSdoComu.c EplSdoUdpu.c EplStatusu.c EplTimeruGeneric.c
  group OpenPOWERLINK/OjDicts
    ../../openPowerlinkLwip/openPowerlinkLwip/Drivers/openPOWERLINK/ObjDicts/Api_CN/: Objdict.c
  group OpenPOWERLINK/Target
    ../../openPowerlinkLwip/openPowerlinkLwip/Drivers/openPOWERLINK/Target/STM32F407/: STM32F4Timer.c
  group OpenPOWERLINK/Edrv
    ../../openPowerlinkLwip/openPowerlinkLwip/Drivers/openPOWERLINK/Edrv/: EdrvF407.c
  group Application/BLDC
    ../../bldcSTM32/bldcSTM32/System/: app.c app_adc.c app_nunchuk.c app_ppm.c app_sten.c app_uartcomm.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_wwdg.c
  group Application/User
    ../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../openPowerlinkLwip/openPowerlinkLwip/Src/: eplTask.c ethernetif.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c event_groups.c timers.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
